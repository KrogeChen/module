<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\system_tick_fm33lc025n.ewp</path>
  </project>
  <batchBuild/>
</workspace>


