# IAR project system_tick_fm33lc025n.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: FM33LC02x FMSH FM33LC02x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: FM33LC0XX; USE_FULL_ASSERT; MFANG; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: $PROJ_DIR$; lib_fm33lc0x; lib_fm33lc0x\CMSIS\Inculde; lib_fm33lc0x\FM33LC0xx_FL_Driver\Inc; lib_fm33lc0x\CMSIS\Device\FM\FM33xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: system_tick_fm33lc025n.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: app_cfg.h main.c
  group mde/mde_pilot_light
    ../../../../mde/mde_pilot_light/: mde_pilot_light.c mde_pilot_light.h solid_pilot_light.h
  group mde/mde_pilot_light/depend
    ../../../../mde/mde_pilot_light/depend/: bsp_pilot_light.c bsp_pilot_light.h bsp_pilot_light_fm33lc025n.h
  group pbc
    ../../: pbc_system_tick.c pbc_system_tick.h
  group pbc/pbc_libraries
    lib_fm33lc0x/FM33LC0xx_FL_Driver/Src/: fm33lc0xx_fl_gpio.c
  group pbc/pbc_libraries/cmsis
    lib_fm33lc0x/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
  group pbc/pbc_libraries/startup
    lib_fm33lc0x/CMSIS/Device/FM/FM33xx/Source/Templates/iar/: startup_fm33lc0xx.s
  group pbc/pbc_system_tick/depend
    ../../depend/: bsp_system_tick.c bsp_system_tick.h bsp_system_tick_fm33lc025n.h
