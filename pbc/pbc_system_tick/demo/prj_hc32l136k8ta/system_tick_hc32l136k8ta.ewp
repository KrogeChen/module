# IAR project system_tick_hc32l136k8ta.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L136K8TA HDSC HC32L136K8TA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; lib_hc32l13x; lib_hc32l13x\common; lib_hc32l13x\driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: system_tick_hc32l136k8ta.out
  ILINK.IlinkIcfFile: lib_hc32l13x\hc32l13x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: app_cfg.h main.c
  group pbc/pbc_lib
    lib_hc32l13x/common/: interrupts_hc32l13x.c system_hc32l13x.c
    lib_hc32l13x/: startup_hc32l13x.s
  group pbc/pbc_system_tick
    ../../: pbc_system_tick.c pbc_system_tick.h
  group pbc/pbc_system_tick/depend
    ../../depend/: bsp_system_tick.c bsp_system_tick.h
