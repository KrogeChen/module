<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mbus_link_hc32l136k8ta.ewp</path>
  </project>
  <batchBuild/>
</workspace>


