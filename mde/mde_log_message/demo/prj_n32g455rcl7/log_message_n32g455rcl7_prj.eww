<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\log_message_n32g455rcl6.ewp</path>
  </project>
  <batchBuild/>
</workspace>


