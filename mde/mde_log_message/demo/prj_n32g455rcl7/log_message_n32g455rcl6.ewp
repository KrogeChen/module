# IAR project log_message_n32g455rcl6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G455RC Nations N32G455RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G45X; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; lib_n32g45x\firmware\CMSIS\core; lib_n32g45x\firmware\CMSIS\device; lib_n32g45x\firmware\n32g45x_std_periph_driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: log_message_n32g455rcl6.srec
  ILINK.IlinkOutputFile: log_message_n32g455rcl6.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: app_cfg.h main.c
  group mde/mde_log_message
    ../../: mde_log_message.c mde_log_message.h
  group mde/mde_log_message/depend
    ../../depend/: bsp_log_message.c bsp_log_message.h bsp_log_message_n32g455rcl7.h
  group pbc/pbc_libraries
    lib_n32g45x/firmware/n32g45x_std_periph_driver/src/: n32g45x_flash.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_tim.c n32g45x_usart.c
  group pbc/pbc_libraries/cmsis
    lib_n32g45x/firmware/n32g45x_std_periph_driver/src/: misc.c
    lib_n32g45x/firmware/CMSIS/device/: system_n32g45x.c
  group pbc/pbc_libraries/startup
    lib_n32g45x/firmware/CMSIS/device/startup/: startup_n32g45x_EWARM.s
  group pbc/pbc_system_tick
    ../../../../pbc/pbc_system_tick/: pbc_system_tick.c pbc_system_tick.h
  group pbc/pbc_system_tick/depend
    ../../../../pbc/pbc_system_tick/depend/: bsp_system_tick.c bsp_system_tick.h
